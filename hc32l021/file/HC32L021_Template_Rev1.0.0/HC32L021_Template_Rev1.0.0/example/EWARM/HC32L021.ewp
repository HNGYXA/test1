# IAR project HC32L021.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: HC32L021C8PB XHSC HC32L021C8PB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../source; ../../common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HC32L021.hex
  ILINK.IlinkOutputFile: HC32L021.out
  ILINK.IlinkIcfFile: config\linker\XHSC\HC32L021C8PB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\source; ..\..\common
  OBJCOPY.OOCOutputFile: HC32L021.srec
  group common
    ./: startup_hc32l021.s
    ../../common/: system_hc32l021.c
  group README
    ../: Readme.txt
  group source
    ../source/: main.c
