# Keil uVision project HC32L021.uvprojx, settings and files
target HC32L021_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.0.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L021 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG
  c include: ../source;../../common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ../../common/: system_hc32l021.c
    ./: startup_hc32l021.s
  group source
    ../source/: main.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
