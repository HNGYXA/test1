# Keil uVision project adc_scan_sqr_ctrim_trig.uvprojx, settings and files
target adc_scan_sqr_ctrim_trig_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.1.0.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adc_scan_sqr_ctrim_trig +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l021.s
    ../../../../mcu/common/: system_hc32l021.c interrupts_hc32l021.c board_stkhc32l021.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c adc.c ctrim.c
  group README
    ../: readme.txt
  group MYIIC
    ../source/: myiic.c
software components: CMSIS:CORE 5.4.0
