# Keil uVision project spi_master_transmit_simplex.uvprojx, settings and files
target spi_master_transmit_simplex_Release (6100001::V6.10.1::.\ARMCLANG)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.1.0.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: spi_master_transmit_simplex +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l021.s
    ../../../../mcu/common/: system_hc32l021.c interrupts_hc32l021.c board_stkhc32l021.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c flash.c gpio.c spi.c sysctrl.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
