<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vc_vref_1p5_falling_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


